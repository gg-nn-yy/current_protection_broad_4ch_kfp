# Keil uVision project ARM.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ARM +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,
  c include: ..\Arm_Kernel;..\STM32_Hal\inc;..\System;..\Driver_Common;..\Middle_Filter;..\App_Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group App_Common
    ../App_Common/: main.c stm32f0xx_it.c sensor_app.c
  group Middle_Fliter
    ../Middle_Filter/: filter_middleware.c
  group Driver_Common
    ../Driver_Common/: led_driver.c rs485_driver.c ads1118_driver.c
  group System
    ../System/: debug.h systick.c system_stm32f0xx.c
  group STM32_Hal
    ../STM32_Hal/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_usart.c
  group ARM_Kernel
    ../Arm_Kernel/: startup_stm32f0xx.s
software components: CMSIS:CORE 5.4.0
